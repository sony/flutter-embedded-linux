LICENSE = "Unknown & MIT & Apache-2.0"
LIC_FILES_CHKSUM = "file://LICENSE;md5=c2c05f9bdd5fc0b458037c2d1fb8d95e \
                    file://third_party/schema/LICENSE-MIT;md5=09b77fb74986791a3d4a0e746a37d88f \
                    file://third_party/six/LICENSE.txt;md5=530f34047c21ad45b3199946dd90bea5 \
                    file://third_party/httplib2/LICENSE;md5=20d3a3fc2f5e478f0425d86732fdb482 \
                    file://third_party/colorama/LICENSE.txt;md5=b4936429a56a652b84c5c01280dcaa26 \
                    file://third_party/repo/COPYING;md5=3b83ef96387f14655fc854ddc3c6bd57 \
                    file://third_party/retry_decorator/LICENSE.google;md5=0d26ea49cb8aa6a059e5c13a1f4f3c22"

SRC_URI = "git://chromium.googlesource.com/chromium/tools/depot_tools.git;protocol=https"
